options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: tetrapol_tx
    output_language: python
    run_options: run
    title: TETRAPOL TX
  states: {}

blocks:
- name: resample
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8000*oversample*resample
  states: {}
- name: args
  id: parameter
  parameters:
    label: osmosdr args
    short_id: a
    type: str
    value: ''
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.25'
    samples_per_symbol: oversample
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: '380000000'
  states: {}
- name: freq_offs
  id: parameter
  parameters:
    label: Freq offset
    type: intx
    value: '200000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offs
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: Input file name
    short_id: i
    type: str
    value: ''
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: args
    bb_gain0: '20'
    bw0: 1e6
    corr0: ppm
    freq0: freq+freq_offs
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: Output file name
    short_id: o
    type: str
    value: ''
  states: {}
- name: oversample
  id: parameter
  parameters:
    label: oversample
    type: intx
    value: '10'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: PPM
    type: intx
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: resample
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_1, '0', osmosdr_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
